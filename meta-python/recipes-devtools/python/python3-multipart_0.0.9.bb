LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=3d98f0d58b28321924a89ab60c82410e"

SRC_URI[sha256sum] = "03f54688c663f1b7977105f021043b0793151e4cb1c1a9d4a11fc13d622c4026"

inherit pypi python_hatchling

PYPI_PACKAGE = "python_multipart"
